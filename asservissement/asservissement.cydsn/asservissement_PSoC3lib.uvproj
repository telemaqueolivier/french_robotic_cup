# Keil uVision project asservissement_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: asservissement_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h uart_pc.c uart_pc.h uart_pc_PM.c uart_pc_INT.c quaddec_left.c quaddec_left.h quaddec_left_INT.c quaddec_left_PM.c encoder_left_sig_a_aliases.h encoder_left_sig_a.c encoder_left_sig_a.h encoder_left_sig_b_aliases.h encoder_left_sig_b.c encoder_left_sig_b.h timer_asserv.c timer_asserv.h timer_asserv_PM.c isr_positionning.c isr_positionning.h quaddec_right.c quaddec_right.h quaddec_right_INT.c quaddec_right_PM.c encoder_right_sig_a_aliases.h encoder_right_sig_a.c encoder_right_sig_a.h encoder_right_sig_b_aliases.h encoder_right_sig_b.c encoder_right_sig_b.h pwm_right.c pwm_right.h pwm_right_PM.c pwm_left.c pwm_left.h pwm_left_PM.c pwm_right_control_reg.c pwm_right_control_reg.h pwm_left_control_reg.c pwm_left_control_reg.h mot_right_backward_aliases.h mot_right_backward.c mot_right_backward.h mot_right_forward_aliases.h mot_right_forward.c mot_right_forward.h mot_left_backward_aliases.h mot_left_backward.c mot_left_backward.h mot_left_forward_aliases.h mot_left_forward.c mot_left_forward.h quaddec_left_isr.c quaddec_left_isr.h quaddec_left_Cnt16.c quaddec_left_Cnt16.h quaddec_left_Cnt16_PM.c quaddec_right_isr.c quaddec_right_isr.h quaddec_right_Cnt16.c quaddec_right_Cnt16.h quaddec_right_Cnt16_PM.c CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: asservissement_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
